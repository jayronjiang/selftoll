# IAR project uCOS-III.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe174
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\uCOS-III; ..\..\BSP; ..\..\BSP\IAR; ..\..\BSP\OS\uCOS-III; ..\..\..\..\..\uC-CSP\MCU\; ..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx\LPC1768; ..\..\..\..\..\uC-CSP\MCU\NXP\LPC17xx; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\CSP; ..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR; ..\..\..\..\..\EvalBoards\NXP\LPC1768-SK\LPC17XXCMSIS\Core\CM3\CoreSupport; ..\..\..\..\..\EvalBoards\NXP\LPC1768-SK\LPC17XXCMSIS\Core\CM3\DeviceSupport\NXP\LPC17xx; ..\..\..\..\..\EvalBoards\NXP\LPC1768-SK\LPC17XXCMSIS\Drivers\include; ..\..\..\..\..\uC-Serial\Driver\NXP\LPC17xx; ..\..\..\..\..\uC-Serial\Driver\NXP; ..\..\..\..\..\uC-Serial\Line; ..\..\..\..\..\uC-Serial\OS\uCOS-III; ..\..\..\..\..\uC-Serial\OS; ..\..\..\..\..\uC-Serial\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOSIII-ZMachine.hex
  ILINK.IlinkOutputFile: uCOSIII-ZMachine.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\LPC1768_FLASH512K_SRAM32K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../: app.c app_hooks.c app_serial.c Box.c Buzz.c cpu_cfg.h csp_cfg.h Global.c Hpi.c i2c.c I2C24C02.c includes.h Key.c Lcd.c Moto.c os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ./: app_cfg.h
  group BSP
    ../../BSP/: bsp.c bsp.h
    ../../BSP/IAR/: cstartup.c LPC1768_FLASH512K_SRAM32K.icf
  group BSP/OS
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group CMSIS-CM3
    ../../LPC17XXCMSIS/Core/CM3/CoreSupport/: core_cm3.c
    ../../LPC17XXCMSIS/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Drivers
    ../../LPC17XXCMSIS/Drivers/source/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group uC/CPU
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/ARM-Cortex-M3/IAR
    ../../../../../uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group uC/CSP/MCU
    ../../../../../uC-CSP/MCU/: csp.c csp.h csp_types.h
  group uC/CSP/MCU/NXP/LPC17xx
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/: csp_gpio.c csp_grp.h csp_int.c csp_pm.c csp_tmr.c
  group uC/CSP/MCU/NXP/LPC17xx/LPC1768
    ../../../../../uC-CSP/MCU/NXP/LPC17xx/LPC1768/: csp_dev.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/Ports/ARM-Cortex-M3/IAR
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uC/OS-III/Port/ARM-Cortex-M3/CSP
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/CSP/: os_csp.h
  group uC/OS-III/Port/ARM-Cortex-M3/CSP/Generic
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/CSP/Generic/: os_csp.c
  group uC/OS-III/Port/ARM-Cortex-M3/Generic/IAR
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../../../../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/Serial
    ../../../../../uC-Serial/Source/: serial.c serial_buf.c
    ../../../../../uC-Serial/Driver/NXP/LPC17xx/: serial_bsp_lpc17xx.c
    ../../../../../uC-Serial/Driver/NXP/: serial_drv_lpcxxxx.c
    ../../../../../uC-Serial/Line/: serial_line_dflt.c serial_line_probe.c serial_line_tty.c
    ../../../../../uC-Serial/OS/uCOS-III/: serial_os.c
